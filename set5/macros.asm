READ MACRO
    MOV AH,8
    INT 21H
ENDM    

READPRINT MACRO
    MOV AH,1
    INT 21H
ENDM 

PRINT MACRO CHAR
    PUSH AX
    PUSH DX
    MOV DL,CHAR
    MOV AH,2
    INT 21H
    POP DX
    POP AX
ENDM

PRINT_STR MACRO MSG
    PUSH AX
    PUSH DX
    MOV DX, OFFSET MSG
    MOV AH,9
    INT 21H
    POP DX
    POP AX
ENDM

NEWLINE MACRO
    PUSH BX
    MOV BL,13
    PRINT BL
    MOV BL,10
    PRINT BL
    POP BX
ENDM

TABS MACRO   
    PUSH AX
    PUSH DX
    MOV DL,9
    MOV AH,2
    INT 21H
    POP DX
    POP AX
ENDM

PRINT_NUM MACRO CHAR   
    PUSH AX
    PUSH DX
    MOV DL, CHAR
    ADD DL, 30H
    MOV AH,2
    INT 21H
    POP DX
    POP AX
ENDM
    
EXIT MACRO
    MOV AX,4C00H
    INT 21H
ENDM



